<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bare_metal_f411.ewp</path>
    </project>
    <batchBuild />
</workspace>
