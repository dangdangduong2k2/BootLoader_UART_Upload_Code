# IAR project bare_metal_f411.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\0.application; ..\1.driver\0.user_driver\0.delay; ..\1.driver\1.peripheral_driver\0.clock; ..\1.driver\1.peripheral_driver\1.gpio; ..\1.driver\1.peripheral_driver\2.uart; ..\1.driver; ..\1.driver\1.peripheral_driver; ..\2.system\1.it_handle; ..\2.system\0.system_handle; D:\1.MCU\STM32\1.Projects\bare\2.system; ..\1.driver\0.user_driver\1.boot
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bare_metal_f411.hex
  ILINK.IlinkOutputFile: bare_metal_f411.out
  ILINK.IlinkIcfFile: D:\1.MCU\STM32\1.Projects\app2\2.system\stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 1.app
    ../0.application/: main.c main.h
  group 2.driver/0.user_driver/0.delay
    ../1.driver/0.user_driver/0.delay/: delay.c delay.h
  group 2.driver/0.user_driver/1.boot_handle
    ../1.driver/0.user_driver/1.boot/: boot.c boot.h
  group 2.driver/1.peripheral_driver
    ../1.driver/1.peripheral_driver/: peripheral_driver_handle.h
  group 2.driver/1.peripheral_driver/0.clock
    ../1.driver/1.peripheral_driver/0.clock/: clock.c clock.h
  group 2.driver/1.peripheral_driver/1.gpio
    ../1.driver/1.peripheral_driver/1.gpio/: gpio.c gpio.h
  group 2.driver/1.peripheral_driver/2.uart
    ../1.driver/1.peripheral_driver/2.uart/: uart.c uart.h
  group 3.system
    ../2.system/: hw_stm32f407vet6.h startup_stm32f407xx.s stm32f407xE.icf
  group 3.system/0.system_handle
    ../2.system/0.system_handle/: system_handle.c system_handle.h
  group 3.system/1.it_handle
    ../2.system/1.it_handle/: it.c it.h
